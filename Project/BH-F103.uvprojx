# Keil uVision project BH-F103.uvprojx, settings and files
target Project (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: -Oz
  c include: ..\User;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\Hardware\DELAY;..\Hardware\EXTI;..\Hardware\USART;..\Hardware\OLED;..\Hardware\sys;..\Hardware\SGP30;..\Hardware\iic2;..\Hardware\ESP8266;..\Hardware\LED;..\Hardware\CountSensor;..\Hardware\Timer;..\Hardware\KEY;..\Hardware\DHT11;..\Hardware\MQ4;..\Hardware\GPS;..\Hardware\MPU6050;..\Hardware\MPU6050\eMPL;..\Hardware\DMA;..\Hardware\ADC;..\Hardware\TIM;..\Hardware\EXTI;..\Hardware\DS18B20;..\Hardware\DS1302;..\Hardware\MAX30102;..\Hardware\STMFLASH;..\Hardware\Flash;..\Hardware\MyRTC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group Hardware
    ../Hardware/DELAY/: systick.c
    ../Hardware/USART/: usart.c
    ../Hardware/sys/: sys.c
    ../Hardware/OLED/: oled.c
    ../Hardware/iic2/: iic2.c
    ../Hardware/LED/: led.c
    ../Hardware/KEY/: Key.c
    ../Hardware/DHT11/: dht11.c
    ../Hardware/MQ4/: mq4.c
    ../Hardware/MPU6050/: mpu6050.c mpudata.c mpuiic.c
    ../Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Hardware/DMA/: dma.c
    ../Hardware/ADC/: adc.c
    ../Hardware/TIM/: timer.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/DS18B20/: ds18b20.c
    ../Hardware/MAX30102/: algorithm.c max30102.c myiic.c
    ../Hardware/Flash/: Store.c MyFLASH.c
    ../Hardware/MyRTC/: MyRTC.c
    ../Hardware/GPS/: gps.c
    ../Hardware/ESP8266/: esp8266.c
